# Keil uVision project Project.uvprojx, settings and files
target WeGui_RGB (6230000::V6.23::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32E230
  c include: ..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\Lcd_Port;..\..\GD32E230;..\..\Lcd_Driver;..\..\Lcd_WeGui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group GD32E23x_standard_peripheral
    ../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group App
    ../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
    ../: gd32e23x_it.c systick.c main.c
  group Lcd_Port
    ../Lcd_Port/: lcd_driver_config.h lcd_wegui_config.h gd32e230_lcd_soft_4spi_port.c gd32e230_lcd_hard_4spi_port.c gd32e230_lcd_soft_3spi_port.c gd32e230_lcd_soft_i2c_port.c gd32e230_lcd_hard_i2c_port.c gd32e230_lcd_dma_4spi_port.c gd32e230_wegui_6key_port.c gd32e230_wegui_4key_port.c gd32e230_wegui_uart_port.c gd32e230_lcd_other_port.c
  group Lcd_Driver
    ../../Lcd_Driver/: lcd_driver.h lcd_driver.c lcd_res.h lcd_res.c gc9a01.c sh1106.c sh1107.c sh1108.c sh1115.c ssd1306.c ssd1309.c ssd1312.c ssd1315.c ssd1327.c st7735.c st7789v3.c st7789vw.c st7796s.c
  group Lcd_WeGui
    ../../Lcd_WeGui/: user_wegui_menu.c lcd_wegui_driver.c lcd_wegui_menu_app.c lcd_wegui_menu_mlist.c lcd_wegui_tip.c
software components: CMSIS:CORE 6.1.1
